Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Gunnar-M-Stängd.IFC
Time: 2025-01-09T09:07:10
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10238
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 10239
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 30121_Gunnar 2,5 m
In: Default Storey
Material: Galvanized Steel

# IfcBuildingElementProxy: 30165_2,5m
In: Default Storey
Material: 6060-F22 (Hydro)

# IfcBuildingElementProxy: 30222_2.5 m
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 40231 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 40363
In: Default Storey
Material: Zinc Alloy, cast

# IfcBuildingElementProxy: 40364
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Gunnar SB-Kappa_Gunnar Motor 2,5m
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Wiberger-din125_8-4^Gunnar-M (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Wiberger-din912_m8x20.step (4)
In: Default Storey
Material: Steel
